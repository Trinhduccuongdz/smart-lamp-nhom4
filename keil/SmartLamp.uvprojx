# Keil uVision project SmartLamp.uvprojx, settings and files
target SmartLamp (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smart_lamp +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\app\inc;..\bsp\inc;..\middlewares\inc;..\hal\inc;..\middlewares\FreeRTOS\include;..\middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\platform\cmsis\core;..\platform\cmsis\device;..\platform\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../platform/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../platform/cmsis/device/: system_stm32f10x.c
  group StdPeriph_Driver
    ../platform/StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_tim.c
  group FreeRTOS
    ../middlewares/FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c
    ../middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../middlewares/FreeRTOS/portable/MemMang/: heap_4.c
  group HAL
    ../hal/src/: hal_clock.c hal_gpio.c hal_exti.c hal_spi.c hal_i2c.c hal_uart.c hal_rtc.c hal_flash.c hal_timer.c hal_nvic.c
  group BSP
    ../bsp/src/: board.c button.c light_sensor.c max7219.c ssd1306.c font5x7.c
  group Middlewares
    ../middlewares/src/: console.c cpu_monitor.c xprintf.c rtc_clock.c settings_store.c
  group App
    ../: main.c
    ../app/src/: app_ipc.c task_input.c task_lamp.c lamp_fsm.c menu.c task_display.c effects.c task_log.c task_console.c task_monitor.c icons.c hooks.c
    ../app/inc/: FreeRTOSConfig.h app_ipc.h app_cfg.h task_input.h task_lamp.h task_display.h task_log.h task_console.h task_monitor.h
